# Keil uVision project boot24lu1p-f32.uvproj, settings and files
target Target 1 (MCS-51)
  device: nRFLU1P-F32 Nordic Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF) XRAM (0x8000-0x87FF) CLOCK(16000000) MODC2
  output: boot24lu1p-f32 +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: ..\..\compiler\c51
  link misc: REMOVEUNUSED
  group Application
    ./: STARTUP.A51 main.c usb.c bootloader.c flash.c usb_desc_bootloader.c

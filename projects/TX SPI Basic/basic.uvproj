# Keil uVision project basic.uvproj, settings and files
target Target 1 (MCS-51)
  device: nRF24LE1 Nordic Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x03FF) XRAM2(0xFA00-0xFFFF) CLOCK(24000000) MODC2 MDU_R515
  output: basic +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\compiler\c51;..\..\hal\nrf24le1;..\..\hal;..\..\hal\nrf24l01p
  group Prog
    ./: STARTUP.A51 main.c
  group HAL
    ../../hal/nrf24le1/: hal_nrf_hw.c hal_spi.c

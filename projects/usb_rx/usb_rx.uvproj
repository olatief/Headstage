# Keil uVision project usb_rx.uvproj, settings and files
target Target 1 (MCS-51)
  device: nRFLU1P-F32 Nordic Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF) XRAM (0x8000-0x87FF) CLOCK(16000000) MODC2
  output: usb_rx +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: MCU_NRF24LU1P
  c include: ..\usb_rx;..\..\compiler\c51;..\..\hal\nrf24lu1p;..\..\hal\nrf24l01p
  group Application
    ./: STARTUP.A51 main.c usb_desc_bulk.c
    ../../hal/nrf24lu1p/: hal_usb.c hal_nrf_hw.c cklf.c cpu.c
    ../../hal/nrf24l01p/: hal_nrf.c

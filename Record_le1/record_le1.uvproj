# Keil uVision project record_le1.uvproj, settings and files
target Target 1 (MCS-51)
  device: nRF24LE1 Nordic Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x03FF) XRAM2(0xFA00-0xFFFF) CLOCK(24000000) MODC2 MDU_R515
  output: record_le1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: C:\Nordic Semiconductor\nRFgo SDK 2.2.0.270\source_code\hal;C:\Nordic Semiconductor\nRFgo SDK 2.2.0.270\source_code\hal\nrf24le1;C:\Nordic Semiconductor\nRFgo SDK 2.2.0.270\source_code\hal\nrf24l01p
  group Source Group 1
    ./: STARTUP.A51 main.c
  group HAL
    C:/Nordic Semiconductor/nRFgo SDK 2.2.0.270/source_code/hal/nrf24le1/: hal_spi.c hal_nrf_hw.c
    C:/Nordic Semiconductor/nRFgo SDK 2.2.0.270/source_code/hal/nrf24l01p/: hal_nrf.c
